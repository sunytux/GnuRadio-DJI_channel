<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>10</value></param>
<param><key>minsize</key><value>10</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>djilink_scenario</key>
<param><key>id</key><value>djilink_scenario_0</value></param>
</block>
<block>
<key>howto_square_ff</key>
<param><key>id</key><value>howto_square_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>newTest_newScenario</key>
<param><key>id</key><value>newTest_newScenario_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>int</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>-100</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>howto_square_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>djilink_scenario_0</sink_block_id><source_key>pdus</source_key><sink_key>scenario_msg</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>newTest_newScenario_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>howto_square_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>newTest_newScenario_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
