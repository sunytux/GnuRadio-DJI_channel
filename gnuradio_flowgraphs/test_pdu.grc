<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0</value></param>
<param><key>k</key><value>pmt.intern("key")</value></param>
<param><key>v</key><value>pmt.intern("123")</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>10</value></param>
<param><key>minsize</key><value>10</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0_1_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_pdu_set_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>pyqt_meta_text_output_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
