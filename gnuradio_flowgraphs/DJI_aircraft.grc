<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>DJI_aircraft</key>
<param><key>id</key><value>DJI_aircraft_0</value></param>
</block>
<block>
<key>DJI_sender</key>
<param><key>id</key><value>DJI_sender_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TAKE_OFF")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<connection><source_block_id>DJI_sender_0</source_block_id><sink_block_id>DJI_aircraft_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>DJI_sender_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
</flow_graph>
